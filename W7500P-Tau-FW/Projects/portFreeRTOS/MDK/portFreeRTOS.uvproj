# Keil uVision project portFreeRTOS.uvproj, settings and files
target portFreeRTOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: portFreeRTOS +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: uC99=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: ..\..\..\Libraries\CMSIS\Device\WIZnet\W7500\Include;..\..\..\Libraries\W7500x_stdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Include;..\;..\..\..\Utilities\FreeRTOSv9.0.0\FreeRTOS\Source\include;..\..\..\Utilities\FreeRTOSv9.0.0\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\..\Utilities\print_x
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x_FreeRTOS.s
  group W7500_Periph
    ../../../Libraries/W7500x_stdPeriph_Driver/src/: W7500x_gpio.c W7500x_crg.c W7500x_uart.c
  group CMSIS
    ../../../Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group User
    ../: main.c W7500x_it.c
  group FreeRTOSv9.0.0
    ../../../Utilities/FreeRTOSv9.0.0/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../Utilities/FreeRTOSv9.0.0/FreeRTOS/Source/: tasks.c list.c queue.c croutine.c event_groups.c timers.c
    ../../../Utilities/FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group print_x
    ../../../Utilities/print_x/: print_x.c
