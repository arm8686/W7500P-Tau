# Keil uVision project portFatFsR012b.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: W7500x_GPIO_Blink_LED +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: ..\..\..\Libraries\CMSIS\Device\WIZnet\W7500\Include;..\..\..\Libraries\W7500x_stdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Include;..\;..\..\..\Utilities\ff12b\src
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x.s
  group W7500_Periph
    ../../../Libraries/W7500x_stdPeriph_Driver/src/: W7500x_gpio.c W7500x_crg.c
  group CMSIS
    ../../../Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group User
    ../: main.c W7500x_it.c
  group ff12b
    ../../../Utilities/ff12b/src/: diskio_w7500p.c ff.c
