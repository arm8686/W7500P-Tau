# Keil uVision project W7500x_SSP_SD_Card_LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: W7500x_SSP_SD_Card_LED +hex
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Libraries\CMSIS\Device\WIZnet\W7500\Include;..\..\..\..\..\Libraries\W7500x_stdPeriph_Driver\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\;..\..\..\..\..\Utilities\print_x
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK-ARM
    ../../../../../Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x.s
  group W7500_Periph
    ../../../../../Libraries/W7500x_stdPeriph_Driver/src/: W7500x_gpio.c W7500x_ssp.c
  group CMSIS
    ../../../../../Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group User
    ../: main.c mmc_sd.c W7500x_it.c
    ../../../../../Utilities/print_x/: print_x.c
